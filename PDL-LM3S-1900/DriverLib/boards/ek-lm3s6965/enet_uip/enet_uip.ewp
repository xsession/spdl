# IAR project enet_uip.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S6965
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\third_party\uip-1.0\uip; ..\..\..\third_party\uip-1.0\apps\httpd
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.r79
  group Source
    ../../../utils/: cspy.c
    ./: enet_uip.c startup_ewarm.c
    ../../../third_party/uip-1.0/apps/httpd/: httpd.c
    ../: osram128x64x4.c
    ../../../third_party/uip-1.0/uip/: uip.c uip_arp.c
