# IAR project boot_demo2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3S101 Luminary LM3S101
  ICCARM.CCDefines: ewarm; PART_LM3S101
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  XLINK.XclFile: boot_demo2.xcl
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.r79
  group Source
    ./: boot_demo2.c startup_ewarm.c
    ../: pdc.c
