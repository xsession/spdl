# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S2965
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Source
    ./: blinky.c startup_ewarm.c
