# IAR project qs_ek-lm3s2965_revc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S2965
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.r79
  group Source
    ./: audio.c can_net.c game.c images.c qs_ek-lm3s2965_revc.c random.c screen_saver.c sounds.c startup_ewarm.c
    ../: rit128x96x4.c
