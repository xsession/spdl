# Keil uVision project qs_ek-lm3s2965_revc.uvproj, settings and files
target qs_ek-lm3s2965_revc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM3S2965 Luminary Micro
  cpu: IRAM(0x20000000-0x2000ffff) IROM(0-0x3ffff) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: qs_ek-lm3s2965_revc
  AfterMake: fromelf --bin --output .\rvmdk\qs_ek-lm3s2965_revc.bin .\rvmdk\qs_ek-lm3s2965_revc.axf
  c flags: Optim=3
  c define: rvmdk PART_LM3S2965
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group Source
    ./: audio.c can_net.c game.c images.c qs_ek-lm3s2965_revc.c random.c screen_saver.c sounds.c startup_rvmdk.S
    ../: rit128x96x4.c
  group Libraries
    ../../../src/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
