# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3S801 Luminary LM3S801
  ICCARM.CCDefines: ewarm; PART_LM3S801
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Source
    ./: blinky.c startup_ewarm.c
