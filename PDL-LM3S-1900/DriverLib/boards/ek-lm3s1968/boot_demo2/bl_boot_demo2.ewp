# IAR project bl_boot_demo2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S1968
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .
  XLINK.XclFile: ..\..\..\boot_loader\bl_link.xcl
  group Source
    ../../../boot_loader/: bl_autobaud.c bl_i2c.c bl_main.c bl_packet.c bl_ssi.c bl_startup_ewarm.S bl_uart.c
