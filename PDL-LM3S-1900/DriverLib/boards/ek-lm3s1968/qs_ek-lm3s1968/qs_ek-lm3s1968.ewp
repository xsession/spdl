# IAR project qs_ek-lm3s1968.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S1968
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.r79
  group Source
    ../: class-d.c rit128x96x4.c
    ./: game.c images.c qs_ek-lm3s1968.c random.c screen_saver.c sounds.c startup_ewarm.c
