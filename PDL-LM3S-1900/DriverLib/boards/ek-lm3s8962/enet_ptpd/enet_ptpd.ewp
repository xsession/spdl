# IAR project enet_ptpd.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\third_party\lwip-1.2.0\src\include; ..\..\..\third_party\lwip-1.2.0\src\include\ipv4; ..\..\..\third_party\lwip-1.2.0\port; ..\..\..\third_party\lwip-1.2.0\apps\httpd; ..\..\..\third_party\ptpd-1rc1\src; ..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.r79
  group Source
    ../../../third_party/ptpd-1rc1/src/: arith.c bmc.c protocol.c
    ../../../utils/: cspy.c uartstdio.c ustdlib.c
    ../../../third_party/lwip-1.2.0/src/core/: dhcp.c inet.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./: enet_lwip.c enet_ptpd.c lmi_fs.c random.c startup_ewarm.c
    ../../../third_party/lwip-1.2.0/src/netif/: etharp.c
    ../../../third_party/lwip-1.2.0/apps/httpd/: httpd.c
    ../../../third_party/lwip-1.2.0/src/core/ipv4/: icmp.c ip.c ip_addr.c
    ../../../third_party/lwip-1.2.0/port/: luminaryif.c
    ../../../third_party/ptpd-1rc1/src/dep-lmi/: ptpd_msg.c ptpd_net.c ptpd_servo.c ptpd_timer.c
    ../: rit128x96x4.c
