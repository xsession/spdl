# IAR project can_device_led.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: LM3Sx1xx Luminary LM3Sx1xx
  ICCARM.CCDefines: ewarm; PART_LM3S2110
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ewarm
  XLINK.XclFile: ..\..\..\ewarm\standalone.xcl
  group Libraries
    ../../../src/ewarm/Exe/: driverlib.r79
  group Source
    ./: can_device_led.c startup_ewarm.c
    ../../../utils/: cspy.c
